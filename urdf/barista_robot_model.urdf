Commit message: Finished task 2

File: urdf/barista_robot_model.urdf (robot description, URDF)
Before this commit: robot barista_bot, 16 links, 15 joints
Joints:
- joint main_body_to_back_yaw_joint: origin xyz=-0.128 0 -0.0878 rpy=0 0 0 -> xyz=-0.120 0 -0.0878 rpy=0 0 0
